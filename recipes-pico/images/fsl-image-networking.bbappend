IMAGE_FEATURES += "package-management"