FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-ls1046apscb-initial-firmware-for-ddr-add-more.patch"

