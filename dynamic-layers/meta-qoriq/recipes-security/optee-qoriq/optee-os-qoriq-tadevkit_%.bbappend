PLATFORM_FLAVOR:ls1046apscb  = "ls1046ardb"
OPTEEMACHINE:ls1046apscb     = "ls-ls1046ardb"

PLATFORM_FLAVOR:ls1046apscbc = "ls1046ardb"
OPTEEMACHINE:ls1046apscbc    = "ls-ls1046ardb"

PLATFORM_FLAVOR:ls1046apxcp  = "ls1046ardb"
OPTEEMACHINE:ls1046apxcp     = "ls-ls1046ardb"

PLATFORM_FLAVOR:ls1046apscbx5 = "ls1046ardb"
OPTEEMACHINE:ls1046apscbx5    = "ls-ls1046ardb"
