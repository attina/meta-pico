PSEUDO_IGNORE_PATHS .= ",${TMPDIR}/work-shared"
