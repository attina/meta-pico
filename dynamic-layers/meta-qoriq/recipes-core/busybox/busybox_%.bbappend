FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " file://syslog-startup.conf \
        "