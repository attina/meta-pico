FILESEXTRAPATHS:prepend := "${THISDIR}/secure-boot-qoriq:"
