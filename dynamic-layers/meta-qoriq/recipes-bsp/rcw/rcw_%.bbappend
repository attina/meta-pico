FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-picocom-rcw-for-ls1046apscb-and-ls1012aprs314.patch"

