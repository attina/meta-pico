include rkbin-common.inc

S = "${UNPACKDIR}/rockchip-rkbin-git/tools"
