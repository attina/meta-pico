BRANCH = "stable/2402"
SRCREV = "500ac0596126576e278e65a64597e8b87fdc55f8"
PV = "24.02.0"

require vpp-core.inc
