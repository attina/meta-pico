COMPATIBLE_MACHINE = "scbxy"