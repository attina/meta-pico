FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-picocom-apply-patches-for-ls1046apscb-board.patch"

