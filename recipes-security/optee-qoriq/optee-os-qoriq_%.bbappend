FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-picocom-add-optee-support-for-ls1046apscb-and-ls1012.patch"

